# Keil uVision project rt1050_QSPI.uvprojx, settings and files
target RT1050_QSPI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt1050_qspi_flashloader
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\MIMXRT105x_QSPI_8MB_SEC.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1052DVL6B,SKIP_SYSCLK_INIT
  c misc: --diag_suppress=61,66,1296,186
  c include: drivers, drivers\..
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group drivers
    ./drivers/: fsl_common.c fsl_flexspi.c fsl_gpio.c pin_mux.c fsl_clock.c clock_config.c system_MIMXRT1052.c flexspiflashdrv.c flexspiflashlut.c
software components: CMSIS:CORE 5.1.1
